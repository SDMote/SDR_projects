options:
  parameters:
    generate_options: no_gui
    id: capture_nRF
    output_language: python
    run_options: run
    title: capture_nRF
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 2423e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10000e3
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/nrf_IQ.dat
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate/20)
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '10000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(centre_freq)
    gain1: '''manual'''
    manual_gain1: '30'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1000e3
    win: window.WIN_HAMMING
  states: {}

connections:
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_correctiq_0, '0']
- [low_pass_filter_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
