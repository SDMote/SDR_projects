options:
  parameters:
    generate_options: qt_gui
    id: OQPSK_coherent
    output_language: python
    title: OQPSK_coherent
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {state: disabled}
- name: offset
  id: variable_qtgui_range
  parameters:
    comment: increased range with FLL
    gui_hint: 6,0
    start: '-500e3'
    step: 1e3
    stop: 500e3
    value: '0'
  states: {}
- name: output_sps
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: plot_N
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(4e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(4)
  states: {}
- name: tuning_LPF_cutoff_kHz
  id: variable_qtgui_range
  parameters:
    comment: |-
      Default value: 2MHz (4MHz in total)
      Assume 4MHz sampling eventually
    gui_hint: 13,0
    start: '1000'
    step: '1'
    stop: '5000'
    value: '2000'
  states: {}
- name: analog_agc_xx_1_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation)/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      Assume sampling 
      rate integer multiple 
      of symbol rate
    delay: int(sps/2)
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/diego/Documents/SDR_projects/capture_nRF/data/802154_capture2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    minoutbuf: 2**16
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/40
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    comment: 500 kHz/V
    samp_rate: samp_rate
    sensitivity: '-2*math.pi*500e3'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi/100
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi/50
  states: {}
- name: digital_fll_band_edge_cc_0_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: |-
      Samples Per Symbol: sps
      Filter Rolloff Factor: assumes RCC filter. Use 1 to approximate HSS
      Prototype Filter Size (FIR taps): sps*2+1
      Loop Bandwidth: 2*math.pi/sps/100
    filter_size: sps*2+1
    rolloff: '1'
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/500
  states: {state: disabled}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      Matched filter: half-sine shape
      sps + 1: this way the taps are symmetrical,
      from zero to zero, covering the whole symbol
    decim: '1'
    taps: np.sin(np.linspace(0, np.pi, sps + 1))
    type: ccc
  states: {state: bypassed}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: tuning_LPF_cutoff_kHz*1000
    decim: decimation
    gain: '1'
    interp: '100'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/100
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: makes most sense if "Output Samples/Symbol" is 1
    gui_hint: 17,0
    label1: after Symbol Sync
    label2: after Costas
    nconnections: '2'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: makes most sense if "Output Samples/Symbol" is 1
    gui_hint: 17,0
    label1: after Symbol Sync
    label2: after Costas
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 12,0
    label1: Eye Diagram for Receive Symbol Sync Re
    label2: Eye Diagram for Receive Symbol Sync  Im
    marker1: '0'
    marker2: '0'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_eye_sink_x_0_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 16,0
    label1: Eye Diagram after Costas Re
    label2: Eye Diagram after Costas  Im
    marker1: '0'
    marker2: '0'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color2: '"green"'
    fc: '0'
    fftsize: 1024*8
    gui_hint: 8,0
    label1: Received Raw
    label2: Received FLL
    label3: Receive FLL Band-Edge
    nconnections: '3'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 11,0
    label1: Receive Symbol Sync Re
    label2: Receive Symbol Sync Im
    marker1: '0'
    marker2: '0'
    size: 10*sps
    srate: samp_rate/sps*output_sps
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 18,0
    label1: Receive after Costas Re
    label2: Receive after Costas Im
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0
    label1: freq
    label2: phase
    label3: error
    nconnections: '3'
    size: '50000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    color1: '3'
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '160E-6'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_agc_xx_1_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_agc_xx_1_0, '0', digital_fll_band_edge_cc_0_0, '0']
- [analog_agc_xx_1_0, '0', virtual_sink_1, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '1']
- [blocks_delay_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '2']
- [blocks_multiply_xx_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0_0_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0_0, '1']
- [digital_fll_band_edge_cc_0_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [digital_fll_band_edge_cc_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0_0, '0', virtual_sink_1, '0']
- [digital_fll_band_edge_cc_0_0, '1', qtgui_time_sink_x_0_0_1, '0']
- [digital_fll_band_edge_cc_0_0, '2', qtgui_time_sink_x_0_0_1, '1']
- [digital_fll_band_edge_cc_0_0, '3', qtgui_time_sink_x_0_0_1, '2']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_0_0_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_1, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_vco_c_0, '0']
- [virtual_source_0, '0', analog_agc_xx_1_0, '0']
- [virtual_source_0_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
