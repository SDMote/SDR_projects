options:
  parameters:
    generate_options: qt_gui
    id: BLE_packet_example
    output_language: python
    title: BLE_packet_example
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: int(250e3)
  states: {}
- name: plot_N_bits
  id: variable
  parameters:
    value: '1136'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: samples_per_bit
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tuning_LPF_cutoff_kHz
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,0
    start: '1'
    step: '1'
    stop: '2000'
    value: '1000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/diego/Documents/SDR_projects/capture_nRF/data/BLE.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/10
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01010101000111100110101000101100010010000000000000000000'
    tagname: length start
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samples_per_bit
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class tag_payload_start(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Tag Payload Start",
                  in_sig=[np.uint8],  # Input is binary stream
                  out_sig=[np.uint8],  # Pass-through output stream
              )
              self.tag_key = gr.pmt.intern("length start")  # Tag to search for
              self.buffer = []  # Buffer to hold data across chunks
              self.buffer_offset = None  # Store tag offset if tag spans chunks

          def work(self, input_items, output_items):
              in_data = input_items[0]  # Input stream
              out_data = output_items[0]  # Output stream
              nread = self.nitems_read(0)  # Number of items read so far on input
              tags = self.get_tags_in_window(0, 0, len(in_data))  # Tags in current window

              # Copy input to output (pass-through block)
              out_data[:] = in_data

              for tag in tags:
                  if tag.key == self.tag_key:  # Look for "length start" tag
                      tag_pos_window = tag.offset - nread  # Position of the tag in the current window
                      
                      # Ensure there is data to extract the length byte
                      if tag_pos_window + 8 <= len(in_data):
                          # Extract 8 bits following the tag               
                          payload_length_bits = in_data[tag_pos_window:tag_pos_window + 8] 

                          # Convert LSB to MSB 8 bits to integer
                          payload_length = 0
                          for i, bit in enumerate(payload_length_bits):
                              payload_length |= (bit << i)

                          # Add a new tag for the start of the payload
                          self.add_item_tag(
                              0,  # Output port
                              tag.offset + 8,  # Absolute position of the payload start
                              gr.pmt.intern(f"payload start"),
                              gr.pmt.from_long(payload_length),  # Length of the payload
                          )

              return len(in_data)
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      filter to only pass
      information around 0Hz
    cutoff_freq: tuning_LPF_cutoff_kHz*1000
    decim: decimation
    gain: '1'
    interp: '100'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/100
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 16,0
    label1: '"Quad Demodded"'
    label2: '"Sliced"'
    marker2: '0'
    name: '"Synced and downsampled"'
    nconnections: '2'
    size: int(1/ decimation *plot_N_bits)
    srate: int(samp_rate / samples_per_bit)
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 15,0
    label1: '"Quad Demodded"'
    name: '"Quad Demodded"'
    size: int(samples_per_bit/ decimation *plot_N_bits)
    srate: int(samp_rate)
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 17,0
    label1: '"correlate output"'
    marker1: '0'
    name: '"correlate output"'
    size: int(1/ decimation *plot_N_bits)
    srate: int(samp_rate / samples_per_bit)
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_1_0, '0']
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [epy_block_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
