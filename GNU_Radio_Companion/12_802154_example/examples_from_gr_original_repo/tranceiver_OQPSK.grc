options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: transceiver_OQPSK
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: default_LO_freq
  id: variable
  parameters:
    value: int(2450e6)
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {}
- name: pluto_LO_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0
    start: default_LO_freq-5e6
    step: 5e6
    stop: default_LO_freq+5e6
    value: default_LO_freq
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(4e6)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello World!\n")
    period: '1000'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'True'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '1000'
    pad_tail: '1000'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {state: disabled}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(pluto_LO_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: pluto_LO_freq
    gain1: '''manual'''
    manual_gain1: '10'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: note_0
  id: note
  parameters:
    note: This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 4e6
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee802_15_4_rime_stack_0, bcin]
- [foo_packet_pad2_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, foo_wireshark_connector_0, in]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad2_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', iio_pluto_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', qtgui_freq_sink_x_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, blocks_message_debug_0, print]
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_rime_stack_0, bcout, network_socket_pdu_0, pdus]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [iio_pluto_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [network_socket_pdu_0, pdus, ieee802_15_4_rime_stack_0, bcin]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
