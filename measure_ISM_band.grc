options:
  parameters:
    generate_options: qt_gui
    id: measure_ISM_band
    output_language: python
    title: measure_ISM_band
  states: {}

blocks:
- name: centre_freq
  id: variable
  parameters:
    value: 2425e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4000e3
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(centre_freq)
    gain1: '''manual'''
    manual_gain1: '20'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: centre_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_correctiq_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
